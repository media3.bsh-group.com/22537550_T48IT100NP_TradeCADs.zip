Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [TrimBim], ExchangeRequirement [Any]
File name: T48IT100NP_TradeCAD.ifc
Time: 2023-06-05T14:54:16
Author: jsink
Organization: Trimble
Written by: Trimble SketchUp
Made in: Trimble SketchUp
Authorization: IFC4 model

# IfcBuildingElementProxy, Undefined
T48IT100NP_TradeCAD.dxf - ObjectType: SketchupComponentInstance
